// 0.96" 80x160 ST7735S on SPI (dongle-s3-0.96: SCLK 10, MOSI 11, CS 12, DC 13, RST 14, backlight always on).
// Driven with IDF's ST7789 panel driver: same command set for what we use (SLPOUT/MADCTL/COLMOD/CASET/RASET).
#include "lcd.h"
#include "sdkconfig.h"
#if CONFIG_DONGLE_BOARD_LCD096

#include <string.h>

#include "driver/spi_master.h"
#include "esp_heap_caps.h"
#include "esp_lcd_panel_io.h"
#include "esp_lcd_panel_ops.h"
#include "esp_lcd_panel_st7789.h"
#include "esp_log.h"
#include "freertos/FreeRTOS.h"
#include "freertos/semphr.h"

#define W 160  // landscape
#define H 80
// Panel calibration for this module (80x160 window inside the controller's 132x162 RAM).
#define GAP_X 1
#define GAP_Y 26
#define MIRROR_X false
#define MIRROR_Y true
#define INVERT true  // IPS panel

static esp_lcd_panel_handle_t s_panel;
static uint16_t *s_fb;  // RGB565, byte-swapped for SPI
static SemaphoreHandle_t s_lock, s_done;  // s_done: the DMA is finished with s_fb

static bool on_done(esp_lcd_panel_io_handle_t io, esp_lcd_panel_io_event_data_t *e, void *ctx)
{
    BaseType_t woken = pdFALSE;
    xSemaphoreGiveFromISR(s_done, &woken);
    return woken == pdTRUE;
}

// 5x8 ASCII font, 0x20..0x7E, column-major, LSB = top row.
static const uint8_t FONT[][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, {0x00, 0x00, 0x5F, 0x00, 0x00}, {0x00, 0x07, 0x00, 0x07, 0x00}, {0x14, 0x7F, 0x14, 0x7F, 0x14},
    {0x24, 0x2A, 0x7F, 0x2A, 0x12}, {0x23, 0x13, 0x08, 0x64, 0x62}, {0x36, 0x49, 0x56, 0x20, 0x50}, {0x00, 0x05, 0x03, 0x00, 0x00},
    {0x00, 0x1C, 0x22, 0x41, 0x00}, {0x00, 0x41, 0x22, 0x1C, 0x00}, {0x2A, 0x1C, 0x7F, 0x1C, 0x2A}, {0x08, 0x08, 0x3E, 0x08, 0x08},
    {0x00, 0x50, 0x30, 0x00, 0x00}, {0x08, 0x08, 0x08, 0x08, 0x08}, {0x00, 0x60, 0x60, 0x00, 0x00}, {0x20, 0x10, 0x08, 0x04, 0x02},
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, {0x00, 0x42, 0x7F, 0x40, 0x00}, {0x42, 0x61, 0x51, 0x49, 0x46}, {0x21, 0x41, 0x45, 0x4B, 0x31},
    {0x18, 0x14, 0x12, 0x7F, 0x10}, {0x27, 0x45, 0x45, 0x45, 0x39}, {0x3C, 0x4A, 0x49, 0x49, 0x30}, {0x01, 0x71, 0x09, 0x05, 0x03},
    {0x36, 0x49, 0x49, 0x49, 0x36}, {0x06, 0x49, 0x49, 0x29, 0x1E}, {0x00, 0x36, 0x36, 0x00, 0x00}, {0x00, 0x56, 0x36, 0x00, 0x00},
    {0x08, 0x14, 0x22, 0x41, 0x00}, {0x14, 0x14, 0x14, 0x14, 0x14}, {0x00, 0x41, 0x22, 0x14, 0x08}, {0x02, 0x01, 0x51, 0x09, 0x06},
    {0x3E, 0x41, 0x5D, 0x59, 0x4E}, {0x7C, 0x12, 0x11, 0x12, 0x7C}, {0x7F, 0x49, 0x49, 0x49, 0x36}, {0x3E, 0x41, 0x41, 0x41, 0x22},
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, {0x7F, 0x49, 0x49, 0x49, 0x41}, {0x7F, 0x09, 0x09, 0x09, 0x01}, {0x3E, 0x41, 0x49, 0x49, 0x7A},
    {0x7F, 0x08, 0x08, 0x08, 0x7F}, {0x00, 0x41, 0x7F, 0x41, 0x00}, {0x20, 0x40, 0x41, 0x3F, 0x01}, {0x7F, 0x08, 0x14, 0x22, 0x41},
    {0x7F, 0x40, 0x40, 0x40, 0x40}, {0x7F, 0x02, 0x0C, 0x02, 0x7F}, {0x7F, 0x04, 0x08, 0x10, 0x7F}, {0x3E, 0x41, 0x41, 0x41, 0x3E},
    {0x7F, 0x09, 0x09, 0x09, 0x06}, {0x3E, 0x41, 0x51, 0x21, 0x5E}, {0x7F, 0x09, 0x19, 0x29, 0x46}, {0x46, 0x49, 0x49, 0x49, 0x31},
    {0x01, 0x01, 0x7F, 0x01, 0x01}, {0x3F, 0x40, 0x40, 0x40, 0x3F}, {0x1F, 0x20, 0x40, 0x20, 0x1F}, {0x3F, 0x40, 0x38, 0x40, 0x3F},
    {0x63, 0x14, 0x08, 0x14, 0x63}, {0x07, 0x08, 0x70, 0x08, 0x07}, {0x61, 0x51, 0x49, 0x45, 0x43}, {0x00, 0x7F, 0x41, 0x41, 0x00},
    {0x02, 0x04, 0x08, 0x10, 0x20}, {0x00, 0x41, 0x41, 0x7F, 0x00}, {0x04, 0x02, 0x01, 0x02, 0x04}, {0x40, 0x40, 0x40, 0x40, 0x40},
    {0x00, 0x01, 0x02, 0x04, 0x00}, {0x20, 0x54, 0x54, 0x54, 0x78}, {0x7F, 0x48, 0x44, 0x44, 0x38}, {0x38, 0x44, 0x44, 0x44, 0x20},
    {0x38, 0x44, 0x44, 0x48, 0x7F}, {0x38, 0x54, 0x54, 0x54, 0x18}, {0x08, 0x7E, 0x09, 0x01, 0x02}, {0x18, 0xA4, 0xA4, 0xA4, 0x7C},
    {0x7F, 0x08, 0x04, 0x04, 0x78}, {0x00, 0x44, 0x7D, 0x40, 0x00}, {0x40, 0x80, 0x84, 0x7D, 0x00}, {0x7F, 0x10, 0x28, 0x44, 0x00},
    {0x00, 0x41, 0x7F, 0x40, 0x00}, {0x7C, 0x04, 0x18, 0x04, 0x78}, {0x7C, 0x08, 0x04, 0x04, 0x78}, {0x38, 0x44, 0x44, 0x44, 0x38},
    {0xFC, 0x24, 0x24, 0x24, 0x18}, {0x18, 0x24, 0x24, 0x18, 0xFC}, {0x7C, 0x08, 0x04, 0x04, 0x08}, {0x48, 0x54, 0x54, 0x54, 0x20},
    {0x04, 0x3F, 0x44, 0x40, 0x20}, {0x3C, 0x40, 0x40, 0x20, 0x7C}, {0x1C, 0x20, 0x40, 0x20, 0x1C}, {0x3C, 0x40, 0x30, 0x40, 0x3C},
    {0x44, 0x28, 0x10, 0x28, 0x44}, {0x1C, 0xA0, 0xA0, 0xA0, 0x7C}, {0x44, 0x64, 0x54, 0x4C, 0x44}, {0x00, 0x08, 0x36, 0x41, 0x00},
    {0x00, 0x00, 0x7F, 0x00, 0x00}, {0x00, 0x41, 0x36, 0x08, 0x00}, {0x08, 0x04, 0x08, 0x10, 0x08},
};
_Static_assert(sizeof(FONT) / sizeof(FONT[0]) == 0x7F - 0x20, "font must cover 0x20..0x7E");

// Draws up to `max` chars at scale `s`; returns chars drawn. shortcut: non-ASCII (e.g. Korean names) shows as '?'.
static int text(int x, int y, int s, uint16_t color, const char *str, int max)
{
    uint16_t c565 = (uint16_t)(color << 8 | color >> 8);
    int n = 0;
    for (; *str && n < max; str++, n++, x += 6 * s) {
        unsigned ch = (unsigned char)*str;
        const uint8_t *g = FONT[(ch < 0x20 || ch > 0x7E ? '?' : ch) - 0x20];
        for (int col = 0; col < 5; col++) {
            for (int row = 0; row < 8; row++) {
                if (!(g[col] >> row & 1)) {
                    continue;
                }
                for (int dy = 0; dy < s; dy++) {
                    for (int dx = 0; dx < s; dx++) {
                        int px = x + col * s + dx, py = y + row * s + dy;
                        if (px < W && py < H) {
                            s_fb[py * W + px] = c565;
                        }
                    }
                }
            }
        }
    }
    return n;
}

void lcd_show(const char *state, uint16_t color, const char *name, const char *addr)
{
    if (!s_panel) {
        return;
    }
    xSemaphoreTake(s_lock, portMAX_DELAY);
    memset(s_fb, 0, W * H * 2);
    text(2, 2, 2, color, state, 13);
    int n = text(2, 24, 2, 0xFFFF, name, 13);  // name: 2 lines x 13 chars
    if ((int)strlen(name) > n) {
        text(2, 42, 2, 0xFFFF, name + n, 13);
    }
    text(2, 68, 1, LCD_GRAY, addr, 26);
    if (esp_lcd_panel_draw_bitmap(s_panel, 0, 0, W, H, s_fb) == ESP_OK) {
        xSemaphoreTake(s_done, pdMS_TO_TICKS(100));
    }
    xSemaphoreGive(s_lock);
}

void lcd_init(void)
{
    const spi_bus_config_t bus = {.sclk_io_num = 10, .mosi_io_num = 11, .miso_io_num = -1, .quadwp_io_num = -1, .quadhd_io_num = -1,
                                  .max_transfer_sz = W * H * 2};
    const esp_lcd_panel_io_spi_config_t io_cfg = {.cs_gpio_num = 12, .dc_gpio_num = 13, .pclk_hz = 26 * 1000 * 1000,
                                                  .lcd_cmd_bits = 8, .lcd_param_bits = 8, .spi_mode = 0, .trans_queue_depth = 4,
                                                  .on_color_trans_done = on_done};
    const esp_lcd_panel_dev_config_t panel_cfg = {.reset_gpio_num = 14, .rgb_ele_order = LCD_RGB_ELEMENT_ORDER_BGR, .bits_per_pixel = 16};
    esp_lcd_panel_io_handle_t io;

    s_fb = heap_caps_malloc(W * H * 2, MALLOC_CAP_DMA);
    s_lock = xSemaphoreCreateMutex();
    s_done = xSemaphoreCreateBinary();
    if (!s_fb || spi_bus_initialize(SPI2_HOST, &bus, SPI_DMA_CH_AUTO) != ESP_OK ||
        esp_lcd_new_panel_io_spi((esp_lcd_spi_bus_handle_t)SPI2_HOST, &io_cfg, &io) != ESP_OK ||
        esp_lcd_new_panel_st7789(io, &panel_cfg, &s_panel) != ESP_OK) {
        ESP_LOGE("lcd", "init failed");  // the dongle works without its screen
        s_panel = NULL;
        return;
    }
    esp_lcd_panel_reset(s_panel);
    esp_lcd_panel_init(s_panel);
    esp_lcd_panel_invert_color(s_panel, INVERT);
    esp_lcd_panel_swap_xy(s_panel, true);
    esp_lcd_panel_mirror(s_panel, MIRROR_X, MIRROR_Y);
    esp_lcd_panel_set_gap(s_panel, GAP_X, GAP_Y);
    esp_lcd_panel_disp_on_off(s_panel, true);
}
#endif  // CONFIG_DONGLE_BOARD_LCD096
